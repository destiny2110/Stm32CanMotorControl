# Keil uVision project proj.uvprojx, settings and files
target CAN_ControlDCServo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE = 8000000
  c include: .\Inc;.\Matlab
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ./Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Communication
    ./Src/: CAN_service.c
  group Driver
    ./Src/: PWM_driver.c CAN_driver.c
  group Matlab
    ./Matlab/: pid.c pid_data.c
  group Utilities
    ./Src/: delay.c
software components: CMSIS:CORE 5.0.0, Board Support:LED 2.0.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:CAN 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:TIM 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:STM32Cube HAL:USART 1.5.0, Device:Startup 2.5.0
